options:
  parameters:
    author: homero
    generate_options: qt_gui
    id: sistemabase
    output_language: python
    title: sistemabase
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: Nlob_n
  id: variable
  parameters:
    value: '64'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: h
  id: variable
  parameters:
    value: mis_funciones.nyq(Sps, ntaps)
  states: {state: disabled}
- name: h
  id: variable
  parameters:
    value: mis_funciones.rcos(Sps,ntaps,alpha)
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: Nlob_n*Sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: samp_rate_dac
  id: variable
  parameters:
    value: samp_rate*32
  states: {}
- name: E3TRadio_bipolar_decisor_ff_0
  id: E3TRadio_bipolar_decisor_ff
  parameters: {}
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    label0: T1 R1
    label1: T2 R2
    label2: T3 R3
    label3: Eye Diagramm
    num_tabs: '4'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.2'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: b_PSD_f_0
  id: b_PSD_f
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''espectro'''
    Ymax: '4e-6'
    gui_hint: Menu@1:1,0,1,1
    samp_rate: samp_rate
  states: {}
- name: b_binary_bipolar_source1_f_0
  id: b_binary_bipolar_source1_f
  parameters:
    Am: '1.'
  states: {}
- name: b_diezmador_ff_0
  id: b_diezmador_ff
  parameters:
    Paso: Sps
  states: {}
- name: b_eye_diagram_f_0
  id: b_eye_diagram_f
  parameters:
    Delay: int(Sps/2)
    Sps: Sps
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(Sps*3/4)
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: mis_funciones.delta(ntaps)
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: mis_funciones
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import numpy as np
      import math

      def nyq(Sps,ntaps):
          k=np.linspace(-ntaps/2, ntaps/2-1, ntaps)
          h=np.sinc(k/Sps)
          return h
          
      #######################################################
      ##                  Delta                            ##
      #######################################################                       
      def delta(ntaps):
          cerosd=(   [0]*(int(ntaps/2)-1)    )
          cerosdi=(   [0]*(int(ntaps/2))     )
          delta_i= np.concatenate(( cerosdi, ([1]) ))
          delta=np.concatenate(( delta_i, cerosd ))
          return delta
         
      #######################################################
      ##               Forma Coseno Alzado                 ##
      #######################################################                       
      def rcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if abs(k)==Sps/(2.*beta):
                      h[n]=np.sinc(1./(2.*beta))*math.pi/4.
                  else:
                      h[n]=np.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
          Amp=np.amax(h)
          return h/Amp
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: Menu@3:0,0,1,1
    samp_per_symbol: Sps*32
    size: 1024*32
    srate: samp_rate*32
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: Menu@1:1,0,1,1
    label1: T2
    label2: R2
    name: '"Espectro en dB"'
    nconnections: '2'
    type: float
    width1: '3'
    width2: '3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:0,0,1,1
    label1: T1
    label2: R1
    marker1: '0'
    marker2: '7'
    nconnections: '2'
    size: ntaps
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '2'
    width2: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:0,0,1,1
    label1: T2
    label2: R2
    nconnections: '2'
    size: ntaps
    srate: samp_rate
    type: float
    width1: '2'
    width2: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '32'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: T1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: R1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: T1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: T2
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: R2
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: R1
  states: {}

connections:
- [E3TRadio_bipolar_decisor_ff_0, '0', blocks_null_sink_0, '0']
- [E3TRadio_bipolar_decisor_ff_0, '0', virtual_sink_0_1, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [b_binary_bipolar_source1_f_0, '0', interp_fir_filter_xxx_0, '0']
- [b_binary_bipolar_source1_f_0, '0', virtual_sink_0, '0']
- [b_diezmador_ff_0, '0', E3TRadio_bipolar_decisor_ff_0, '0']
- [blocks_add_xx_0, '0', b_diezmador_ff_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0_1, '0']
- [blocks_delay_0, '0', rational_resampler_xxx_0, '0']
- [blocks_vector_source_x_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_vector_source_x_0, '0', virtual_sink_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_add_xx_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_eye_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_0, '0', b_PSD_f_0, '0']
- [virtual_source_0_0, '0', b_eye_diagram_f_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_0_1, '0', blocks_delay_0, '0']
- [virtual_source_0_0_1, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_0_1, '0', qtgui_time_sink_x_0_0, '1']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
